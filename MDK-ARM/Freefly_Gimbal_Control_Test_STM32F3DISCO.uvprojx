# Keil uVision project Freefly_Gimbal_Control_Test_STM32F3DISCO.uvprojx, settings and files
target Freefly_Gimbal_Control_Test_STM32F3DISCO (6230000::V6.23::ARMCLANG)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Freefly_Gimbal_Control_Test_STM32F3DISCO +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F303xC
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;..\Drivers\BSP;..\Drivers\BSP\Components\Common;..\Drivers\BSP\STM32F3-Discovery;..\Drivers\BSP\Components\l3gd20;..\Drivers\BSP\Components\lsm303dlhc;..\QX_Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group BSP
    ../Drivers/BSP/STM32F3-Discovery/: stm32f3_discovery.c stm32f3_discovery_accelerometer.c stm32f3_discovery_gyroscope.c
  group Application/User
    ../Src/: main.c stm32f3xx_it.c stm32f3xx_hal_msp.c FIFO_Buf.c QX_Protocol_App.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Components
    ../Drivers/BSP/Components/l3gd20/: l3gd20.c
    ../Drivers/BSP/Components/lsm303dlhc/: lsm303dlhc.c
  group QX_Protocol
    ../QX_Lib/: QX_Parsing_Functions.c QX_Protocol.c
software components: CMSIS:CORE 6.1.0
